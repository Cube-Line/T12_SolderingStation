# Repository Cube-Line/T12_SolderingStation

## KiCad design 010.Hardware/Ver0.1.1/T12_SolderingStationMain/T12_SolderingStation.kicad_pcb

Parts:
C1, C3: 50V/100nF; C_0603_1608Metric
C2: 10V/22uF; CP_EIA-3528-21_Kemet-B
C4: 50V/10uF; CP_EIA-6032-28_Kemet-C
C5: 50V/100nF; C_0402_1005Metric
C6: 50V/220pF; C_0402_1005Metric
C7: NC; C_0402_1005Metric
C8: 10uF; C_0805_2012Metric
C9, C14: 1uF; C_0603_1608Metric
C10, C11, C13: 100nF; C_0603_1608Metric
C15: 2.2nF; C_0603_1608Metric
D1: SS54; D_SMA
D2: GREEN; LED_0402_1005Metric
D3: BZV55B5V1; D_MiniMELF
D4: 1N4148W; D_SOD-123
D5: SDT10A45P5; PowerDI5
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_Palconn_UTC16-G
J4: Conn_01x05_Female; PhoenixContact_MC_1,5_5-G-3.5_1x05_P3.50mm_Horizontal
J5, J6: Conn_01x06_Female; PinHeader_1x06_P2.54mm_Vertical
JP1, JP2: JUMP; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: L; L_7.3x7.3_H4.5
R1: 6.8K; R_0402_1005Metric
R2: NC; R_0402_1005Metric
R3, R12: 100K; R_0402_1005Metric
R4, R6, R13: 20K; R_0402_1005Metric
R5, R11, R14, R15, R16, R17: 10K; R_0402_1005Metric
R7, R19: 200K; R_0402_1005Metric
R8: 68.1K; R_0402_1005Metric
R9, R10: 5.1K; R_0402_1005Metric
R18: 200k; R_0402_1005Metric
SW1: SW_DPST_Temperature; SW_SPST_Omron_B3FS-100xP
SW2: RotaryEncoder_2; EC10E
TP1: VCC; TestPoint_Pad_1.0x1.0mm
TP2: MISO; TestPoint_Pad_1.0x1.0mm
TP3: MOSI; TestPoint_Pad_1.0x1.0mm
TP4: SCK; TestPoint_Pad_1.0x1.0mm
TP5: RST; TestPoint_Pad_1.0x1.0mm
TP6: GND; TestPoint_Pad_1.0x1.0mm
TP7: TXD; TestPoint_Pad_1.0x1.0mm
TP8: RXD; TestPoint_Pad_1.0x1.0mm
U1: MP1584EN; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm_ThermalVias
U2: CH224D; QFN-20-1EP_3x3mm_P0.4mm_EP1.65x1.65mm_ThermalVias
U3: ATmega328P-A; TQFP-32_7x7mm_P0.8mm
U4: OPA2333xxD; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 16mHz; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm

Connections:
+24V: C4.1, C5.1, D5.3 (K), J4.5, J6.1, J6.2, R3.1, U1.7 (VIN)
/ADC0: R18.2, U3.23 (PC0), U4.1
/ADC1: D3.1 (K), R12.2, R13.1, U3.24 (PC1)
/ADC2: J4.1, U3.25 (PC2)
/BEEP: J5.6, U3.9 (PD5)
/CFG1: R1.2, R2.2, U2.1 (DRV), U2.19 (CFG1), U3.32 (PD2)
/CFG2: JP1.1 (A), U2.13 (CFG2), U3.1 (PD3)
/CFG3: JP2.2 (B), U2.12 (CFG3), U3.2 (PD4)
/D6: C11.1, R11.2, SW1.2, SW1.4, U3.10 (PD6)
/D7: SW2.A, U3.11 (PD7)
/D8: SW2.B, U3.12 (PB0)
/D9: U3.13 (PB1)
/D10: J4.3, R14.2, U3.14 (PB2)
/MISO: TP2.1, U3.16 (PB4)
/MOSI: TP3.1, U3.15 (PB3)
/RST: J5.4, TP5.1, U3.29 (~RESET/PC6)
/RXD: TP8.1, U3.30 (PD0)
/SCK: TP4.1, U3.17 (PB5)
/SCL: J5.3, U3.28 (PC5)
/SDA: J5.2, U3.27 (PC4)
/TXD: TP7.1, U3.31 (PD1)
GND: C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C13.2, C14.2, C15.2, D1.2 (A), D2.1 (K), D3.2 (A), D4.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J4.4, J5.5, J6.3, J6.4, JP2.1 (A), R1.1, R6.2, R7.2, R8.2, R9.2, R10.2, R13.2, R17.1, R19.1, SW1.1, SW1.3, SW2.0 (SHELL), SW2.C, TP6.1, U1.5 (GND), U1.9 (GND), U2.6 (MMOS#), U2.14 (ISP), U2.15 (ISN), U2.21 (GND), U3.3 (GND), U3.5 (GND), U3.21 (GND), U4.4 (V-), Y1.2
unnamed: C1.1, D1.1 (K), L1.1, U1.1 (SW)
unnamed: C1.2, U1.8 (BST)
unnamed: C6.1, C7.1, U1.3 (COMP)
unnamed: C6.2, R8.1
unnamed: C10.1, U3.20 (AREF)
unnamed: C13.1, R15.1, R17.2, U4.5 (+)
unnamed: C15.1, D4.2 (A), R16.2, U4.3 (+)
unnamed: D2.2 (A), R5.2
unnamed: J1.A5 (CC1), R9.1, U2.11 (CC1)
unnamed: J1.A6 (D+), J1.B6 (D+), U2.8 (UDP)
unnamed: J1.A7 (D-), J1.B7 (D-), U2.9 (UDM)
unnamed: J1.B5 (CC2), R10.1, U2.10 (CC2)
unnamed: R3.2, U1.2 (EN)
unnamed: R4.2, R6.1, U1.4 (FB)
unnamed: R7.1, U1.6 (FREQ)
unnamed: R18.1, R19.2, U4.2 (-)
unnamed: U3.7 (XTAL1/PB6), Y1.3
unnamed: U3.8 (XTAL2/PB7), Y1.1
unnamed: U4.6 (-), U4.7
P+: C14.1, J4.2, R16.1
VBUS: C8.1, D5.1 (A), D5.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R12.1, U2.2 (VBUS)
VCC: C2.1, C3.1, J5.1, L1.2, R4.1, R5.1, R11.1, R14.1, R15.2, TP1.1, U3.4 (VCC), U3.6 (VCC), U3.18 (AVCC), U4.8 (V+)
VDD: C9.1, JP1.2 (B), R2.1, U2.7 (VDD)

Notes on the sheet:
1. 单电阻配置方式: CFG_{1}阻值配置: 6.8K --> V_{bus}=9V 24K --> V_{bus}=12V 56K --> V_{bus}=15V NC --> V_{bus}=20V 2. 电平配置方式: CFG_{1} CFG_{2} CFG_{3} V_{bus} 1 - - 5V 0 0 0 9V 0 0 1 12V 0 1 1 15V 0 1 0 20V
USB_PD_POWER
POWER_ADC&BEEP
AVR_ISP
ATMEL328P
Thermocouple Amplifier
ROTARY ENCODER
DC-DC
SOCKET

Board: 2 copper layers, 80.0 x 23.0 mm, 60 parts (24 on the bottom side), 44 nets.

## KiCad design 010.Hardware/T12_SolderingStationScreen/T12_SolderingStationScreen.kicad_pcb

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1: 10uF; CP_EIA-6032-28_Kemet-C
C2, C4, C9, C13: 100nF; C_0603_1608Metric
C3: 10uF; CP_EIA-3528-21_Kemet-B
C5, C6: 1uF; C_0603_1608Metric
C7: 10uF; C_1206_3216Metric
C8, C10, C12: 4.7uF; C_0603_1608Metric
C11: 2.2uF; C_0603_1608Metric
D1: 1N4148; D_SOD-123
J1, J2: Conn_01x06_Female; PinSocket_1x06_P2.54mm_Vertical
JP1: JUMP; SolderJumper-2_P1.3mm_Bridged2Bar_Pad1.0x1.5mm
Q1: S8050; TSOT-23
R1: 100K; R_0402_1005Metric
R2: 10K; R_0402_1005Metric
R3: 2K; R_0402_1005Metric
R4: 560K; R_0402_1005Metric
RN1: 4.7K; R_Array_Concave_4x0402
U1: RT9013-3V3; SOT-23-5
U2: RS0102YH8; VSSOP-8_2.3x2mm_P0.5mm
U3: 0.91_OLED_128x32; OLED_128x32

Connections:
+3V3: C8.1, C9.1, D1.1 (K), JP1.1 (A), RN1.5 (R4.2), RN1.6 (R3.2), RN1.7 (R2.2), RN1.8 (R1.2), U2.8 (VCCA), U3.5 (VBAT), U3.8 (VDD)
+24V: J2.1, J2.2
/BEEP: J1.6, R3.2
/DISP_SCL: RN1.3 (R3.1), U2.7 (A1), U3.10 (SCL)
/DISP_SDA: RN1.2 (R2.1), U2.6 (A2), U3.11 (SDA)
/SCL: J1.3, U2.2 (B1)
/SDA: J1.2, U2.3 (B2)
GND: C1.2, C2.2, C3.2, C4.2, C7.2, C8.2, C9.2, C10.1, C11.2, C12.2, C13.2, J1.5, J2.3, J2.4, Q1.1 (E), R4.2, U1.2 (GND), U2.5 (GND), U3.7 (VSS)
unnamed: BZ1.2 (+), Q1.3 (C)
unnamed: C3.1, C4.1, JP1.2 (B), U1.5 (OUT)
unnamed: C5.1, U3.1 (C2P)
unnamed: C5.2, U3.2 (C2N)
unnamed: C6.1, U3.3 (C1P)
unnamed: C6.2, U3.4 (C1N)
unnamed: C11.1, U3.13 (VCOMH)
unnamed: C12.1, C13.1, U3.14 (VCC)
unnamed: Q1.2 (B), R3.1
unnamed: R1.2, U1.3 (EN)
unnamed: R2.2, U2.4 (OE)
unnamed: R4.1, U3.12 (IREF)
VCC: BZ1.1 (-), C1.1, C2.1, C7.1, J1.1, R1.1, R2.1, U1.1 (IN), U2.1 (VCCB)

Notes on the sheet:
VL_TRANSLATOR
IIC_OLED
3V3_LDO

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
Board: 2 copper layers, 40.0 x 23.0 mm, 27 parts (26 on the bottom side), 22 nets.

## KiCad design 010.Hardware/T12_SolderingStation.kicad_pcb

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1, C3: 50V/100nF; C_0603_1608Metric
C2: 10V/22uF; CP_Elec_5x5.7
C4, C6, C24: 10uF; C_1206_3216Metric
C5, C7, C17, C18, C20, C23, C25: 100nF; C_0603_1608Metric
C8: 50V/10uF; CP_Elec_5x5.7
C9: 50V/100nF; C_0402_1005Metric
C10: 50V/220pF; C_0402_1005Metric
C11: NC; C_0402_1005Metric
C12, C13, C14, C15, C26: 1uF; C_0603_1608Metric
C16, C19, C22: 4.7uF; C_0603_1608Metric
C21: 2.2uF; C_0603_1608Metric
C27: 2.2nF; C_0603_1608Metric
D1: SS54; D_SMB
D2: GREEN; LED_0402_1005Metric
D3: 1N4148; D_SOD-123
D4: BZV55B5V1; D_MiniMELF
D5: 1N4148W; D_SOD-123
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_Palconn_UTC16-G
J2: AVR-ISP-6; PinHeader_2x03_P2.54mm_Vertical
J3: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
J4: Conn_01x05_Female; PhoenixContact_MC_1,5_5-G-3.5_1x05_P3.50mm_Horizontal
JP1, JP2: JUMP; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
L1: L; L_7.3x7.3_H4.5
Q1: S8050; TSOT-23
R1: 6.8K; R_0402_1005Metric
R2: NC; R_0402_1005Metric
R3, R5, R13: 100K; R_0402_1005Metric
R4, R11, R14, R16, R17, R18, R19: 10K; R_0402_1005Metric
R6, R15: 20K; R_0402_1005Metric
R7, R21: 200K; R_0402_1005Metric
R8: 68.1K; R_0402_1005Metric
R9, R10: 5.1K; R_0402_1005Metric
R12: 560K; R_0402_1005Metric
R20: 200k; R_0402_1005Metric
RN1: 4.7K; R_Array_Concave_4x0402
RV1: 50K; Potentiometer_Bourns_3266W_Vertical
SW1: SW_DPST_Temperature; SW_SPST_Omron_B3FS-100xP
SW2: RotaryEncoder_2; EC10E
U1: MP1584EN; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm_ThermalVias
U2: CH224D; QFN-20-1EP_3x3mm_P0.4mm_EP1.65x1.65mm_ThermalVias
U3: RT9013-3V3; SOT-23-5
U4: 0.91_OLED_128x32; OLED_128x32
U5: ATmega328P-A; TQFP-32_7x7mm_P0.8mm
U6: RS0102YH8; VSSOP-8_2.3x2mm_P0.5mm
U7: OPA2333xxD; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 16mHz; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm

Connections:
+3V3: C6.1, C7.1, C16.1, C17.1, D3.1 (K), RN1.5 (R4.2), RN1.6 (R3.2), RN1.7 (R2.2), RN1.8 (R1.2), U3.5 (OUT), U4.5 (VBAT), U4.8 (VDD), U6.8 (VCCA)
/ADC0: R20.2, U5.23 (PC0), U7.1
/ADC1: D4.1 (K), R13.2, R15.1, U5.24 (PC1)
/ADC2: J4.4, U5.25 (PC2)
/BEEP: Q1.2 (B), U5.9 (PD5)
/CFG1: R1.2, R2.2, U2.1 (DRV), U2.19 (CFG1), U5.32 (PD2)
/CFG2: JP1.1 (A), U2.13 (CFG2), U5.1 (PD3)
/CFG3: JP2.2 (B), U2.12 (CFG3), U5.2 (PD4)
/D6: C20.1, R11.2, SW1.2, SW1.4, SW2.B, U5.10 (PD6), U5.12 (PB0)
/D7: SW2.A, U5.11 (PD7)
/D9: U5.13 (PB1)
/D10: J4.3, R16.2, U5.14 (PB2)
/DISP_SCL: RN1.3 (R3.1), U4.10 (SCL), U6.7 (A1)
/DISP_SDA: RN1.2 (R2.1), U4.11 (SDA), U6.6 (A2)
/MISO: J2.1 (MISO), U5.16 (PB4)
/MOSI: J2.4 (MOSI), U5.15 (PB3)
/RST: J2.5 (~RST), RN1.4 (R4.1), U5.29 (~RESET/PC6)
/RXD: J3.3, U5.30 (PD0)
/SCK: J2.3 (SCK), U5.17 (PB5)
/SCL: U5.28 (PC5), U6.2 (B1)
/SDA: U5.27 (PC4), U6.3 (B2)
/TXD: J3.2, U5.31 (PD1)
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C11.2, C12.2, C13.2, C16.2, C17.2, C18.2, C19.1, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, D1.2 (A), D2.1 (K), D4.2 (A), D5.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.6 (GND), J3.4, J4.5, JP2.1 (A), Q1.1 (E), R1.1, R6.2, R7.2, R8.2, R9.2, R10.2, R12.2, R15.2, R19.1, R21.1, SW1.1, SW1.3, SW2.0 (SHELL), SW2.C, U1.5 (GND), U1.9 (GND), U2.6 (MMOS#), U2.14 (ISP), U2.15 (ISN), U2.21 (GND), U3.2 (GND), U4.7 (VSS), U5.3 (GND), U5.5 (GND), U5.21 (GND), U6.5 (GND), U7.4 (V-), Y1.2
unnamed: BZ1.2 (+), Q1.3 (C)
unnamed: C1.1, D1.1 (K), L1.1, U1.1 (SW)
unnamed: C1.2, U1.8 (BST)
unnamed: C10.1, C11.1, U1.3 (COMP)
unnamed: C10.2, R8.1
unnamed: C14.1, U4.1 (C2P)
unnamed: C14.2, U4.2 (C2N)
unnamed: C15.1, U4.3 (C1P)
unnamed: C15.2, U4.4 (C1N)
unnamed: C18.1, U5.20 (AREF)
unnamed: C19.2, D3.2 (A), RN1.1 (R1.1), U4.9 (RES#)
unnamed: C21.1, U4.13 (VCOMH)
unnamed: C22.1, C23.1, U4.14 (VCC)
unnamed: C25.1, R17.1, R19.2, U7.5 (+)
unnamed: C27.1, D5.2 (A), R18.2, U7.3 (+)
unnamed: D2.2 (A), R4.2
unnamed: J1.A5 (CC1), R9.1, U2.11 (CC1)
unnamed: J1.A6 (D+), J1.B6 (D+), U2.8 (UDP)
unnamed: J1.A7 (D-), J1.B7 (D-), U2.9 (UDM)
unnamed: J1.B5 (CC2), R10.1, U2.10 (CC2)
unnamed: R3.2, U1.2 (EN)
unnamed: R5.2, U3.3 (EN)
unnamed: R6.1, RV1.3, U1.4 (FB)
unnamed: R7.1, U1.6 (FREQ)
unnamed: R12.1, U4.12 (IREF)
unnamed: R14.2, U6.4 (OE)
unnamed: R20.1, R21.2, U7.2 (-)
unnamed: U5.7 (XTAL1/PB6), Y1.3
unnamed: U5.8 (XTAL2/PB7), Y1.1
unnamed: U7.6 (-), U7.7
P+: C26.1, J4.2, R18.1
VBUS: C8.1, C9.1, C12.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J4.1, R3.1, R13.1, U1.7 (VIN), U2.2 (VBUS)
VCC: BZ1.1 (-), C2.1, C3.1, C4.1, C5.1, C24.1, J2.2 (VCC), J3.1, L1.2, R4.1, R5.1, R11.1, R14.1, R16.1, R17.2, RV1.1, RV1.2, U3.1 (IN), U5.4 (VCC), U5.6 (VCC), U5.18 (AVCC), U6.1 (VCCB), U7.8 (V+)
VDD: C13.1, JP1.2 (B), R2.1, U2.7 (VDD)

Notes on the sheet:
1. 单电阻配置方式: CFG_{1}阻值配置: 6.8K --> V_{bus}=9V 24K --> V_{bus}=12V 56K --> V_{bus}=15V NC --> V_{bus}=20V 2. 电平配置方式: CFG_{1} CFG_{2} CFG_{3} V_{bus} 1 - - 5V 0 0 0 9V 0 0 1 12V 0 1 1 15V 0 1 0 20V
USB_PD_POWER
POWER_ADC&BEEP
AVR_ISP
ATMEL328P
VL_TRANSLATOR
Thermocouple Amplifier
ROTARY ENCODER
DC-DC
IIC_OLED
3V3_LDO
SOCKET

Board: 2 copper layers, 74 parts (0 on the bottom side), 56 nets, no tracks yet.

## Commit log

2022-07-11 第一次提交
2022-07-12 完成部分原理图
2022-07-21 增加3D文件，完善原理图纸
2022-07-27 更新一点
2022-07-29 更新图纸
2022-08-23 完善图纸
2022-09-05 更新版本
